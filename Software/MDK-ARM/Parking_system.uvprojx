# Keil uVision project Parking_system.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: STM32_Proj +hex
  c flags: OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\HAL\CMSIS;..\HAL\STM32F4xx_HAL_Driver\Inc;..\Drivers\Core;..\Drivers\Esp8266;..\Drivers\Infrared_barrier;..\Drivers\NT35310;..\Drivers\OV7725;..\Drivers\Smoke_sensor;..\Midwares\RT-Thread\components\finsh;..\Midwares\RT-Thread\include;..\Midwares\RT-Thread\include\libc;..\Applications\App;..\Applications\Main
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group HAL/CMSIS
    ../HAL/CMSIS/: core_cm3.c system_stm32f10x.c startup_stm32f10x_hd.s stm32f10x_it.c
  group HAL/STM32F4xx_STD_Driver
    ../HAL/STM32F4xx_HAL_Driver/Src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group Drive/Core
    ../Drivers/Core/: IWDG.c PWM.c SysTick.c USart.c
  group Drive/ESP8266
    ../Drivers/ESP8266/: ESP8266.c
  group Drive/NT35310
    ../Drivers/NT35310/: lcd.c
  group Drive/OV7725
    ../Drivers/OV7725/: OV7725_entrance.c OV7725_exit.c OV7725sccb_entrance.c OV7725sccb_exit.c
  group Drive/Infrared_barrier
    ../Drivers/Infrared_barrier/: Infrared_barrier.c
  group Drive/Smoker_sensor
    ../Drivers/Smoke_sensor/: Smoke_sensor.c
  group Midware/RT-Thread/Kernel
    ../Midwares/RT-Thread/src/: clock.c components.c cpu.c device.c idle.c ipc.c irq.c kservice.c mem.c memheap.c mempool.c object.c scheduler.c slab.c thread.c timer.c
  group Midware/RT-Thread/Ports
    ../Midwares/RT-Thread/libcpu/arm/cortex-m3/: cpuport.c context_rvds.S
  group Midware/RT-Thread/Finsh
    ../Midwares/RT-Thread/components/finsh/: cmd.c msh.c shell.c
  group Application/App
    ../Applications/App/: LCD_Basic_application.c LCD_Interface_design.c License_plate_recognition.c Parking_detection_processing.c Task.c
  group Application/Main
    ../Applications/Main/: main.c board.c config.h rtconfig.h system.c system.h
